# Keil uVision project do_detect.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: do_detect +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE;..\FATFS\src;..\FATFS\exfuns;..\FATFS\src\option;..\HARDWARE\IIC;..\HARDWARE\ADC;..\HARDWARE\DS18B20;..\HARDWARE\UI;..\HARDWARE\oxygen
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c task_general_control.c task_touch_UI.c system_stm32f10x.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/: drv_led.c drv_delay.c drv_wdt.c drv_spi1.c drv_buzzer.c drv_door.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/UI/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c hw_config.c
    ../HARDWARE/oxygen/: oxygen.c
    ../HARDWARE/IIC/: myiic.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_it.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
